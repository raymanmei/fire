# Keil uVision project fire.uvprojx, settings and files
target fire (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: fire
  AfterMake: fromelf --bin --output=fire.bin output\fire.axf
  c flags: Optim=1 OneElfS=1
  c include: ..\driver\inc;..\system;..\main
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group system
    ../system/: startup_hc32l110.s system_hc32l110.c
  group main
    ../main/: main.c main.h com.c com.h
  group driver
    ../driver/src/: ddl.c interrupts_hc32l110.c lpuart.c gpio.c clk.c bt.c
software components: CMSIS:CORE 4.1.0
